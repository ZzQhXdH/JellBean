# Keil uVision project JellyBean.uvprojx, settings and files
target JellyBean (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: JellyBean
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\CMSIS;..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group User
    ../User/: main.cpp
  group User/Task
    ../User/Task/: Task.cpp ReceiverTask.cpp StatusUpdateTask.cpp
  group User/Driver
    ../User/Driver/: LogUart.cpp Motor.cpp MotorManager.cpp MainUart.cpp CurrentAdc.cpp
  group User/Event
    ../User/Event/: Event.cpp Receiver.cpp Sender.cpp LogEvent.cpp MainEvent.cpp
  group User/Custom
    ../User/Custom/: Protocol.cpp DeliverManager.cpp DeliverListener.cpp DeliverObject.cpp BaseOutput.cpp
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS2:Keil RTX5 5.3.0
